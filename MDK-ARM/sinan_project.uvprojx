# Keil uVision project sinan_project.uvprojx, settings and files
target sinan_project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H743VITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.0.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: sinan_project +hex
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32H743xx
  c misc: --cpp11
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;..\User\3-HDL(Hardwware Driver Layer)\inc;..\User\1-APL(Application Layer)\inc;../eigen-3.4.0;..\User\2-MWL(Middleware Layer)\inc
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32h743xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c i2c.c spi.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group 1-APL(Application Layer)
    ../User/1-APL(Application Layer)/src/: INS.cpp VOFA.c Callback_Uart.c UWB.c RTK.c
    ../User/1-APL(Application Layer)/inc/: INS.h VOFA.h Callback_Uart.h UWB.h RTK.h
  group 2-MWL(Middleware Layer)
    ../User/2-MWL(Middleware Layer)/inc/: matrix.h CRC8_CRC16.h coordinate_transformation.h
    ../User/2-MWL(Middleware Layer)/src/: matrix.cpp CRC8_CRC16.c coordinate_transformation.c
  group 3-HDL(Hardwware Driver Layer)
    ../User/3-HDL(Hardwware Driver Layer)/inc/: OLED.h OLED_Font.h imu.h
    ../User/3-HDL(Hardwware Driver Layer)/src/: OLED.c imu.c
software components: CMSIS:CORE 5.5.0, CMSIS:DSP 1.9.0-dev
